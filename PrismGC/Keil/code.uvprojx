# Keil uVision project code.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: code
  AfterMake: fromelf -cvf .\Objects\code.axf --vhx --32x1 -o .\Objects\code.hex
  AfterMake: fromelf -cvf .\Objects\code.axf -o .\Objects\code.txt
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT5: ROM 0x20005800 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0x5800
  group Source Group 1
    ./src/: startup_CMSDK_CM0.s main.c UART.c UART.h BitOperate.h GPIO.h HardwareConfig.h Interrupt.h Sleep.c Sleep.h Peripheral.h GPULite.c GPULite.h Timer.h Buzzer.h Digit.h GlobalDefine.h HDMI.h KeyBoard.h PageBlockGame.c PageBlockGame.h PageMain.c PageMain.h SDRAM.h BGM.c BGM.h Nunchuck.c Nunchuck.h PageI2CTest.c PageI2CTest.h Font.c Font.h Font16.h I2C.c I2C.h console.c console.h fmtio.c fmtio.h PageCharTest.c PageCharTest.h PageMazeGame.c PageMazeGame.h Block.c Block.h BlockMap.c BlockMap.h Charactors.c Charactors.h PageMenu.c PageMenu.h GetKey.c GetKey.h PageEnd.c PageEnd.h
