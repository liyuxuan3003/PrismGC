# Keil uVision project code.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: code
  AfterMake: fromelf -cvf .\Objects\code.axf --vhx --32x1 -o .\Objects\code.hex
  AfterMake: fromelf -cvf .\Objects\code.axf -o .\Objects\code.txt
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./src/: startup_CMSDK_CM0.s main.c UART.c UART.h BitOperate.h GPIO.h HardwareConfig.h Interrupt.h Sleep.c Sleep.h HDMI.c Peripheral.h
