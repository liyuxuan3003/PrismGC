# Keil uVision project BuzzerNLCD.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IROM(0x00000000,0x00400000) IRAM(0x20000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BuzzerNLCD
  AfterMake: fromelf -cvf .\BuzzerNLCD.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\BuzzerNLCD.axf -o code.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../src/: code_def.c code_def.h lcd.c lcdfont.h main.c startup_CMSDK_CM0.s systick.c
