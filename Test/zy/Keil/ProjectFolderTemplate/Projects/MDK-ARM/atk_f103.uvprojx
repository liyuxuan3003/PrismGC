# Keil uVision project atk_f103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c
  group Drivers/system
    ../../../../../../../Keil/【正点原子】精英STM32F103开发板 V2-资料盘(A盘)/4，程序源码/2，标准例程-HAL库版本/实验0 基础入门实验/实验0-2，新建工程实验-寄存器版本/Drivers/SYSTEM/delay/: delay.c
    ../../../../../../../Keil/【正点原子】精英STM32F103开发板 V2-资料盘(A盘)/4，程序源码/2，标准例程-HAL库版本/实验0 基础入门实验/实验0-2，新建工程实验-寄存器版本/Drivers/SYSTEM/sys/: sys.c
    ../../../../../../../Keil/【正点原子】精英STM32F103开发板 V2-资料盘(A盘)/4，程序源码/2，标准例程-HAL库版本/实验0 基础入门实验/实验0-2，新建工程实验-寄存器版本/Drivers/SYSTEM/usart/: usart.c
